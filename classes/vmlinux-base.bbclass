export VMLINUX_LOCATION = "${STAGING_KERNEL_BUILDDIR}/boot"
