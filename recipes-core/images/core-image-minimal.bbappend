CORE_IMAGE_EXTRA_INSTALL_append = "kpatch kpatch-patches"

